# IAR project 01_Project.ewp, settings and files
configuration 01_Project (ARM, debug)
  General.OGChipSelectEditMenu: STM32MP157C_M4 ST STM32MP157C_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: CORE_CM4; NO_ATOMIC_64_SUPPORT; METAL_INTERNAL; METAL_MAX_DEVICE_REGIONS=2; VIRTIO_SLAVE_ONLY; USE_HAL_DRIVER; STM32MP157Cxx
  ICCARM.CCIncludePath2: ../CM4/OPENAMP; ../CM4/Core/Inc; ../Middlewares/Third_Party/OpenAMP/open-amp/lib/include; ../Middlewares/Third_Party/OpenAMP/libmetal/lib/include; ../Drivers/STM32MP1xx_HAL_Driver/Inc; ../Drivers/STM32MP1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32MP1xx/Include; ../Middlewares/Third_Party/OpenAMP/virtual_driver; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 01_Project.hex
  ILINK.IlinkOutputFile: 01_Project.out
  ILINK.IlinkIcfFile: stm32mp15xx_sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32mp15xx.s
  group Application/User/CM4/Core
    ../CM4/Core/Src/: main.c stm32mp1xx_it.c stm32mp1xx_hal_msp.c
  group Application/User/CM4/OPENAMP
    ../CM4/OPENAMP/: mbox_ipcc.c openamp.c rsc_table.c openamp_log.c
  group Drivers/STM32MP1xx_HAL_Driver
    ../Drivers/STM32MP1xx_HAL_Driver/Src/: stm32mp1xx_hal_rcc.c stm32mp1xx_hal_rcc_ex.c stm32mp1xx_hal_gpio.c stm32mp1xx_hal_hsem.c stm32mp1xx_hal_dma.c stm32mp1xx_hal_dma_ex.c stm32mp1xx_hal_mdma.c stm32mp1xx_hal_pwr.c stm32mp1xx_hal_pwr_ex.c stm32mp1xx_hal_cortex.c stm32mp1xx_hal.c stm32mp1xx_hal_exti.c stm32mp1xx_hal_ipcc.c stm32mp1xx_hal_tim.c stm32mp1xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Common/System/: system_stm32mp1xx.c
  group Middlewares/OpenAmp
    ../Middlewares/Third_Party/OpenAMP/open-amp/lib/proxy/: CMakeLists.txt
    ../Middlewares/Third_Party/OpenAMP/libmetal/lib/: device.c init.c io.c log.c shmem.c
    ../Middlewares/Third_Party/OpenAMP/libmetal/lib/system/generic/: condition.c generic_device.c generic_init.c generic_io.c generic_shmem.c time.c
    ../Middlewares/Third_Party/OpenAMP/open-amp/lib/remoteproc/: remoteproc_virtio.c
    ../Middlewares/Third_Party/OpenAMP/open-amp/lib/rpmsg/: rpmsg.c rpmsg_virtio.c CMakeLists.txt
    ../Middlewares/Third_Party/OpenAMP/open-amp/lib/virtio/: virtio.c virtqueue.c
    ../Middlewares/Third_Party/OpenAMP/libmetal/lib/system/generic/template/: sys.c
    ../Middlewares/Third_Party/OpenAMP/virtual_driver/: virt_uart.c
